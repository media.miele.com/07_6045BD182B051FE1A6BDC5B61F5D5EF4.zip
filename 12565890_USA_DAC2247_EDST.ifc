Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 669c0756-6bd6-4d36-a274-6bf587e3e839, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-12T10:16:29+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12565890_USA_DAC2247_EDST:28C2247S_USA_12565890_DAC2247_EDST, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 1165 mm; Height: 296 mm; Depth: 500 mm
Pset_BuildingElementProxyCommon - Reference: 28C2247S_USA_12565890_DAC2247_EDST; sets with these values: 2
